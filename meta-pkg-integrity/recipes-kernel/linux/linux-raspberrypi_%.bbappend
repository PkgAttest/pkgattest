FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://vtpm-proxy.cfg"
