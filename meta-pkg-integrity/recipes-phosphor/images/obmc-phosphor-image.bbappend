inherit pkg-measurements

OBMC_IMAGE_EXTRA_INSTALL:append = " pkg-witness"
